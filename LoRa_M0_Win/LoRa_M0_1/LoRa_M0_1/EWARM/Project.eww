<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LoRa_M0_1.ewp</path>
  </project>
  <batchBuild />
</workspace>
